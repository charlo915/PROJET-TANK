<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\..\..\..\..\N-3\Archi\Toolbox_TP1\TP1.ewp</path>
  </project>
  <batchBuild/>
</workspace>


